# IAR project STM32L151CBU6A_SX1278.ewp, settings and files
configuration STM32L151CBU6A_SX1278 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151CB-A ST STM32L151CB-A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L151xBA
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L1xx/Include; ../Drivers/CMSIS/Include; ../SX1278/platform; ../SX1278/platform/sx12xxEiger; ../SX1278/radio
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L151CBU6A_SX1278.hex
  ILINK.IlinkOutputFile: STM32L151CBU6A_SX1278.out
  ILINK.IlinkIcfFile: stm32l151xba_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l151xba.s
  group Application/User
    ../Src/: dht11.c esp8266.c gpio.c main.c spi.c stm32l1xx_hal_msp.c stm32l1xx_it.c sys.c usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c
  group SX1278/platform
    ../SX1278/platform/sx12xxEiger/: fifo.c sx1276-Hal.c sx12xxEiger.c
  group SX1278/radio
    ../SX1278/radio/: radio.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-LoRa.c sx1276-LoRaMisc.c sx1276.c
