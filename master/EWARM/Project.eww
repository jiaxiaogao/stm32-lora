<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STM32L151CBU6A_SX1278.ewp</path>
    </project>
    <batchBuild />
</workspace>
